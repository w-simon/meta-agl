require ${@bb.utils.contains('AGL_FEATURES', 'aglcore', 'weston_9.0_aglcore.inc', '', d)}
