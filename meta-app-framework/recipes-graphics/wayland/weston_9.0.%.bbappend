require ${@bb.utils.contains('APPFW_ENABLED', '1', 'weston_9.0_appfw.inc', '', d)}
