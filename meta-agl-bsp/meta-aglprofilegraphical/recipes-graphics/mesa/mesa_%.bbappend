# The gallium-llvm is recommended as software 3D graphics renderer
PACKAGECONFIG_append_qemux86 = " gallium-llvm"
PACKAGECONFIG_append_qemux86-64 = " gallium-llvm"
