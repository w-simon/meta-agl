
FILESEXTRAPATHS_append := ":${THISDIR}/files"

SRC_URI_append = " file://0001-Add-FALLTHRU-comment-to-handle-GCC7-warnings.patch"