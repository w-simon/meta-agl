do_configure_append_bbe() {
    echo 'gbm-format=rgb565' >> ${WORKDIR}/core.cfg
    echo 'mode=1280x720' >> ${WORKDIR}/hdmi-a-1-270.cfg
}
