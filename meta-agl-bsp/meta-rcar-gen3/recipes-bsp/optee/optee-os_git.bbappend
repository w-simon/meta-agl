# do_install() nothing
do_install[noexec] = "1"
