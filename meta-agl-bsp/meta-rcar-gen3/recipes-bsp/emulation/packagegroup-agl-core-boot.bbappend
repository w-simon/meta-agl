RDEPENDS_${PN}_append_m3ulcb = "platform-e3-emulation"
