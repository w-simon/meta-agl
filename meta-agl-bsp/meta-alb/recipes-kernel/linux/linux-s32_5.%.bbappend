addtask merge_delta_config before do_kernel_localversion