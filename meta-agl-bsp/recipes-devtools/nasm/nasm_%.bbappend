FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0001-asmlib-Drop-pure-function-attribute-from-seg_init.patch"

