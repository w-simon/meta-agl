FILESEXTRAPATHS_prepend := "${THISDIR}/m4-native:"
SRC_URI_append = " file://m4-1.4.18-glibc-change-work-around.patch "

