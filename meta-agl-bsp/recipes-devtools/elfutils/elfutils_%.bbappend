FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0001-Ensure-that-packed-structs-follow-the-gcc-memory-lay.patch"

